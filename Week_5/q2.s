	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0, =NUM
	LDR R1, [R0]
	LDR R2, =DST
	BL FACT
	STR R1, [R2]
STOP B STOP
FACT	PUSH {R3, LR}
	MOV R3, R1
	CMP R1, #0
	BNE DOWN
	MOV R1, #1
	B DOWN1
DOWN	SUB R1, #1
	BL FACT
	MUL R1, R3
DOWN1	POP {R3, LR}
	BX LR
NUM DCD 6
	AREA mydata, DATA, READWRITE
DST DCD 0
	END