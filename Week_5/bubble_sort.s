	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	MOV R4, #0
	MOV R1, #10
	LDR R0, =LIST
	LDR R2, =DST
UP	LDR R3, [R0,R4]
	STR R3, [R2,R4]
	ADD R4, #4
	SUB R1, #1
	CMP R1, #0
	BHI UP
	LDR R0, =DST
	MOV R3, #10		;INNER LOOP COUNTER
	SUB R3,R3,#1
	MOV R9, R3
	SUB R3,R3,#1
	MOV R9, R3		;OUTER LOOP COUNTER
OUTER_LOOP
	MOV R5,R0
	MOV R4,R3
INNER_LOOP
	LDR R6,[R5],#4
	LDR R7,[R5]
	CMP R7,R6
	STRLS R6,[R5]
	STRLS R7,[R5,#-4]
	SUBS R4,R4,#1
	BNE INNER_LOOP
	SUB R3,#1
	SUBS R9,R9,#1
	BNE OUTER_LOOP
STOP B STOP
LIST DCB 1,5,2,8,3,6,4,9,10,7
	AREA mydata, DATA, READWRITE
DST DCB 0,0,0,0,0
	END