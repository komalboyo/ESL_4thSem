	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0, =VAL1
	LDR R1, =VAL2
	LDR R2, [R0]
	LDR R3, [R1]
	LDR R9, =DST1
	MOV R4, #8
	MOV R8, #0		;FOR CARRY
LOOP	AND R5, R2, #0XF
	AND R6, R3, #0XF
	ADD R5,R8
	MOV R8, #0
	ADD R5, R6
	CMP R5, #0XA
	BLO L1
	SUB R5, #0XA
	ADD R8, #1
L1	STRB R5, [R9], #1
	LSR R2, #4
	LSR R3, #4
	SUBS R4, #1
	BNE LOOP
	BL UNP
STOP B STOP
UNP	LDR R0,=DST1
	LDR R10, =DST2
	MOV R2, #2				;HOLDS THE NUMBER OF BYTES TO BE PACKED
L2	LDRB R5, [R0], #1
	LDRB R6, [R0], #1
	LSL R6, #4
	ADD R5,R6
	STRB R5, [R10], #1
	SUBS R2, #1
	BNE L2
	BX LR
VAL1 DCD 0X111
VAL2 DCD 0x59
	AREA mydata, DATA, READWRITE
DST1 DCD 0
DST2 DCD 0
	END