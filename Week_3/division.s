	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0, =DIVIDEND
	LDR R1, [R0]
	LDR R0, =DIVISOR
	LDR R2, [R0]
	LDR R3, =Q
	LDR R4, =R
	MOV R5,#0
L2	CMP R1, R2
	BCC L1			;CARRY WHEN NO BORROW ie WHEN R1>R2
	SUBS R1,R1,R2
	ADD R5, #1
	B L2
L1	STR R5, [R3]
	STR R1, [R4]
STOP B STOP
DIVIDEND DCD 0X11
DIVISOR DCD 0X5
	AREA mydata, DATA, READWRITE
Q DCD 0
R DCD 0
	END
