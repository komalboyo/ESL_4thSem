	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0, =VAL1
	LDR R1, [R0]
	LDR R0, =VAL2
	LDR R2, [R0]
	LDR R3, =GCD
	LDR R4, =LCM
GCDF CMP R2,R1
	BCC SWAP
	SUBS R1,R1,R2
	BNE GCDF
	MOV R1,R2
	STR R1,[R3]
STOP B STOP
SWAP MOV R5,R1		;SWAP
	MOV R1,R2
	MOV R2,R5
	BX LR
VAL1 DCD 0XA
VAL2 DCD 0X6
	AREA mydata, DATA, READWRITE
GCD DCD 0
LCM DCD 0
	END
